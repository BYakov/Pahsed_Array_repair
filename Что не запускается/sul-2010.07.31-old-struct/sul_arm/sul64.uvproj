# Keil uVision project sul64.uvproj, settings and files
target sul64 (ARM-ADS)
  device: AT91SAM3U4E Atmel
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x20080000-0x20083FFF) IROM(0x80000-0x9FFFF) IROM2(0x100000-0x11FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: sul64 +hex
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=1 wLevel=2
  c define: at91sam3u4 sram NOFPUT  TRACE_LEVEL=4
  c misc: --gnu
  c include: .; .\board;.\cmsis;.\peripherals\systick;.\main;.\peripherals\usart;.\peripherals\irq;.\peripherals\pio;.\peripherals\pmc;.\peripherals\led;.\peripherals\ssc;.\peripherals\dma;.\peripherals\dbgu;.\peripherals\smc;.\peripherals\twi;..\sul_src;.\usb;.\adc;.\peripherals\tc
  memory RVCT4: ROM 0x80000 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20080000 size 0x4000
  scatter file: .\board\sram.sct
  link misc: --entry resetHandler
  group boards
    ./board/: board_cstartup_keil.c board_lowlevel.c exceptions.c
  group peripherials
    ./peripherals/systick/: systick.c
    ./peripherals/usart/: usart.c
    ./peripherals/irq/: nvic.c
    ./peripherals/pio/: pio.c
    ./peripherals/pmc/: pmc.c
    ./peripherals/led/: led.c
    ./peripherals/ssc/: ssc.c
    ./peripherals/smc/: smc.c
    ./peripherals/twi/: twi.c
    ./peripherals/tc/: tc.c
  group main
    ./: dispatch.c exchange.c
    ./main/: main.c
  group cmsis
    ./cmsis/: core_cm3.c
  group utility
    ./utility/: math.c
  group sul_mdo
    ../sul_src/: sul_mdo_cmd.h
  group adc
    ./adc/: adc12.c adc12.h
